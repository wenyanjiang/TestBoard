# Keil uVision project TestSystemV2.uvprojx, settings and files
target TestSystemV2 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TestSystemV2 +hex
  AfterMake: fromelf.exe --bin -o ../@L.bin ./Objects/@L.axf
  AfterMake: CopyHex.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_USB_OTG_HS,USE_ULPI_PHY
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\USB\USB_Device\inc;..\USB\USB_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/: delay.c main.c stm32fxxx_it.c system_stm32f4xx.c bsp.c w25qxx.c process.c tsl2561.c
    ./: CopyHex.bat
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USB Device
    ../USB/USB_Device/src/: usbd_cdc_core.c usbd_core.c usbd_desc.c usbd_ioreq.c usbd_req.c usbd_usr.c
  group USB Driver
    ../USB/USB_Driver/src/: usb_bsp.c usb_core.c usb_dcd_int.c usb_dcd.c
